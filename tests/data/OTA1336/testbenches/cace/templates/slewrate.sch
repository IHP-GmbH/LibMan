** sch_path: tests/data/OTA1336/testbenches/cace/templates/slewrate.sch
**.subckt slewrate
x1 vdd net1 out out inx vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
Vvdd vdd VSUB DC CACE{Vvdd}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvcm net2 VSUB DC CACE{Vcmp}
RSUB VSUB GND 0.01 m=1
Vsig inx net2 pulse(-CACE{ampl} CACE{ampl} 1u 300p 300p 500n 10u)
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control

tran 1n 2u
let in  = inx - CACE{Vcmp} + CACE{ampl}
let out = out - CACE{Vcmp} + CACE{ampl}
let vmax = 2*CACE{ampl}

meas tran t1 When v(out) = 0.1*vmax
meas tran t2 When v(out) = 0.9*vmax
let tdiff = t2-t1
let SR = 0.8e-6*vmax/tdiff
echo $&SR > CACE{simpath}/CACE{filename}_CACE{N}.data
*quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end

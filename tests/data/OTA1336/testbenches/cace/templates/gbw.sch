** sch_path: tests/data/OTA1336/testbenches/cace/templates/gbw.sch
* Open sourced under Apache 2.0 license
**.subckt gbw
VVcm inp VSUB DC CACE{Vcm} AC CACE{Vdiff}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
x1 vdd ena out inm inp vss OTA1336
Ibias ena VSUB DC CACE{Ibias}
L6 out inm 4G m=1
C1 inm VSUB 4G m=1
**** begin user architecture code

.control
* AC parameters derivation
save all
ac dec 1001 1e1 1e9
let vog = db(V(out)/V(inp))
let vph = 180 * unwrap(phase(V(out)) - phase(V(inp)))/pi
let fbw = 0
let pm = 0
let gm = minimum(vog)
meas ac fbw WHEN vog=0 FALL=1
meas ac pm FIND vph WHEN vog=0 FALL=1
meas ac gm FIND vog WHEN vph=-180 FALL=1

let gainbw = $&fbw
let gmargin = -$&gm
let pmargin = 180 + $&pm
echo $&gainbw $&pmargin $&gmargin > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ
.lib cornerRES.lib res_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end

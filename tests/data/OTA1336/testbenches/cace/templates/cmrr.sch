** sch_path: tests/data/OTA1336/testbenches/cace/templates/cmrr.sch
* Open sourced under Apache 2.0 license
**.subckt cmrr
x1 vdd net1 out inm inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
L6 out inm 4G m=1
C1 inm VSUB 4G m=1
V1 inp VSUB DC CACE{Vcm} AC 1 0
x2 vdd net2 out1 inp inp vss OTA1336
Rout1 out1 VSUB CACE{Rout} m=1
Cout1 out1 VSUB CACE{Cout} m=1
Ibias1 net2 VSUB DC CACE{Ibias}
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ
.lib cornerRES.lib res_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
ac dec 1001 10 100meg
let CMRR = db((v(out)/v(inp))/(v(out1)/v(inp)))
meas ac cmrrdb max CMRR
echo $&cmrrdb > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end

** sch_path: tests/data/OTA1336/testbenches/cace/templates/payload/dccurrent_dyn.sch
* Open sourced under Apache 2.0 license
**.subckt dccurrent_dyn
VVcm inm VSUB 3
Vvss vss VSUB 3
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB 3
RSUB VSUB GND 0.01 m=1
VVdiff inp inm 3
x1 vdd net1 out inm inp vss OTA1336
Ibias net1 VSUB 1m
**** begin user architecture code

blabla


blabla

**** end user architecture code
**.ends
.GLOBAL GND
.end

** sch_path: tests/data/OTA1336/testbenches/cace/templates/payload/psrr.sch
* Open sourced under Apache 2.0 license
**.subckt psrr
x1 vdd net1 out out inx vss OTA1336
Ibias net1 VSUB 1m
Vvdd net2 VSUB 3
Vvss vss VSUB 3
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvcm inx VSUB 3
RSUB VSUB GND 0.01 m=1
Vac vdd net2 3
**** begin user architecture code

blabla


blabla

**** end user architecture code
**.ends
.GLOBAL GND
.end

** sch_path: tests/data/OTA1336/testbenches/cace/templates/eqvnoise.sch
* Open sourced under Apache 2.0 license
**.subckt eqvnoise
VVcm inp VSUB DC CACE{Vcm} AC 1.0
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
E1 inn VSUB out VSUB 1.0
x1 vdd net1 out inn inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
**** begin user architecture code

.control
* Closed loop unity gain configuration
noise V(out) VVcm dec 10 CACE{frequency} CACE[CACE{frequency}*1e7]
* Everything having to do with noise is incredibly obscure. . .
setplot noise2
unset sqrnoise
let vn = onoise_total
echo $&vn > CACE{simpath}/CACE{filename}_CACE{N}.data
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end

** sch_path: tests/data/OTA1336/testbenches/cace/templates/overshoot.sch
**.subckt overshoot
x1 vdd net1 out out inx vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
Vvdd vdd VSUB DC CACE{Vvdd}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvcm net2 VSUB DC CACE{Vcmp}
RSUB VSUB GND 0.01 m=1
Vsig inx net2 pulse(0 50m 0 100p 100p 500n 1u)
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
tran 1n 2u
meas tran Vmax MAX v(out) from=750n to=1.5u
let ovshoot = $&vmax/0.65
echo $&ovshoot > CACE{simpath}/CACE{filename}_CACE{N}.data
*quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end

** sch_path: tests/data/OTA1336/testbenches/cace/templates/dccurrent_vdd.sch
* Open sourced under Apache 2.0 license
**.subckt dccurrent_vdd
VVcm inm VSUB DC CACE{Vcm}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
VVdiff inp inm DC CACE{Vdiff}
x1 vdd net1 out inm inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
**** begin user architecture code

.control
op
set wr_singlescale
wrdata CACE{simpath}/CACE{filename}_CACE{N}.data -I(Vvdd)
quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ
.lib cornerRES.lib res_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end

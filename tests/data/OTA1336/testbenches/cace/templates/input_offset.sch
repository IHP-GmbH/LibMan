** sch_path: tests/data/OTA1336/testbenches/cace/templates/input_offset.sch
* Open sourced under Apache 2.0 license
**.subckt input_offset
x1 vdd net1 out inm inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
V2 net3 VSUB DC 0.0
V3 inp net3 DC CACE{Vcm}
V4 inm net2 DC CACE{Vcm}
E1 net2 VSUB net3 VSUB -1
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}_mismatch
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1




.control

  let mc_runs = 10
  let run = 0
  set curplot=new
  set scratch=$curplot
  set appendwrite
  let voff=unitvec(mc_runs)


  dowhile run < mc_runs
    reset
    dc V2 -50m 50m 10u
    meas dc Vin_at when out=0.6
    let Vin2_at = 2*$&Vin_at
    set run = $&run
    set plt = $curplot
    setplot $scratch
    let voff[run]={$plt}.Vin2_at
    setplot $plt
    let run = run + 1
    end
* let mean_offset = mean(abs({$scratch}.voff))
let max_offset = mean(abs({$scratch}.voff)) +  3*stddev({$scratch}.voff)

echo $&max_offset   > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end

** sch_path: tests/data/OTA1336/testbenches/cace/templates/psrr.sch
* Open sourced under Apache 2.0 license
**.subckt psrr
x1 vdd net1 out out inx vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
Vvdd net2 VSUB DC CACE{Vvdd}
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvcm inx VSUB DC CACE{Vcmp}
RSUB VSUB GND 0.01 m=1
Vac vdd net2 DC AC 1
**** begin user architecture code

* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1



.control
ac dec 1 CACE{frequency} CACE{frequency}
let psrrdb = -db(out)
echo $&psrrdb
echo $&psrrdb > CACE{simpath}/CACE{filename}_CACE{N}.data
*quit
.endc


**** end user architecture code
**.ends
.GLOBAL GND
.end

** sch_path: tests/data/OTA1336/testbenches/cace/templates/avo.sch
* Open sourced under Apache 2.0 license
**.subckt avo
Vvss vss VSUB DC CACE{Vvss}
Rout out VSUB CACE{Rout} m=1
Cout out VSUB CACE{Cout} m=1
Vvdd vdd VSUB DC CACE{Vvdd}
RSUB VSUB GND 0.01 m=1
x1 vdd net1 out inm inp vss OTA1336
Ibias net1 VSUB DC CACE{Ibias}
V1 inp VSUB DC CACE{Vcm} AC 1 0
L6 out inm 4G m=1
C1 inm VSUB 4G m=1
**** begin user architecture code

.control
* Open loop gain measured from 100 Hz to 100kHz
ac dec 101 1e2 1e5
let vog = db(v(out) / v(inp))
meas ac vres MAX vog
echo $&vres > CACE{simpath}/CACE{filename}_CACE{N}.data
quit
.endc



* CACE gensim simulation file CACE{filename}_CACE{N}
* Generated by CACE gensim, Efabless Corporation (c) 2023
* Find the current through the amplifier under condition of static input

.include CACE{DUT_path}

.lib cornerMOSlv.lib CACE{corner}
.lib cornerCAP.lib cap_typ

.option TEMP=CACE{temperature}
* Flag unsafe operating conditions (exceeds models' specified limits)
.option warn=1


**** end user architecture code
**.ends
.GLOBAL GND
.end
